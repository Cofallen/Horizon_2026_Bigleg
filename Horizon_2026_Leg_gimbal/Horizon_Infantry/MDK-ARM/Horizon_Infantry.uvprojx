# Keil uVision project Horizon_Infantry.uvprojx, settings and files
target Horizon_Infantry (6180000::V6.18::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)   CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Horizon_Infantry +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,User_Debug
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/CMSIS/Core/Inc;../Middlewares/CMSIS/DSP/Inc/dsp;../Middlewares/CMSIS/DSP/Inc;../Middlewares/CMSIS/DSP/PrivateInclude;../User/Bsp/inc;../User/Algorithm/inc;../User/App/inc;../User/UI;../User/Start/Inc;../Middlewares/SEGGER_RTT/Config;../Middlewares/SEGGER_RTT/RTT;../User/Leg/inc;../Middlewares/ST/AI/Inc;../X-CUBE-AI/App
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Bsp
    ../User/Bsp/inc/: BMI088reg.h BMI088driver.h BMI088Middleware.h bsp_adc.h bsp_buzzer.h bsp_dwt.h bsp_imu_pwm.h can_bsp.h DJI_Motor.h DM_Motor.h NIMING.h Power_CAP.h Referee.h RGBctrl.h RUI_DBUS.h Vision.h VOFA.h CANSPI.h MCP2515.h music.h VT13.h
    ../User/Bsp/: BMI088driver.c BMI088Middleware.c bsp_adc.c bsp_buzzer.c bsp_dwt.c bsp_imu_pwm.c can_bsp.c DJI_Motor.c DM_Motor.c NIMING.c Power_CAP.c Referee.c RGBctrl.c RUI_DBUS.c Vision.c VOFA.c CANSPI.c MCP2515.c music.c VT13.c
  group Algorithm
    ../User/Algorithm/: controller.c CRC_DJI.c kalman_filter.c pid_temp.c Power_Ctrl.c QuaternionEKF.c RUI_MATH.c user_lib.c slidingmodec.c Bottom.c
    ../User/Algorithm/inc/: controller.h CRC_DJI.h kalman_filter.h pid_temp.h Power_Ctrl.h QuaternionEKF.h RUI_MATH.h user_lib.h slidingmodec.h Bottom.h
  group App
    ../User/App/: Chassis_Task.c Gimbal_Task.c IMU_Task.c Robot.c RobotUI_Ctrl.c RUI_ROOT_INIT.c Shoot_Task.c Heat_Task.c
    ../User/App/inc/: Chassis_Task.h Gimbal_Task.h IMU_Task.h Robot.h RobotUI_Ctrl.h RUI_ROOT_INIT.h Shoot_Task.h
  group Start
    ../User/Start/Inc/: log.h All_Init.h MY_Define.h WHW_IRQN.h Motors.h
    ../User/Start/: All_Init.c WHW_IRQN.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group SEGGER_RTT
    ../Middlewares/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group CMSIS
    ../Middlewares/CMSIS/DSP/Src/BasicMathFunctions/: BasicMathFunctions.c
    ../Middlewares/CMSIS/DSP/Src/BayesFunctions/: BayesFunctions.c
    ../Middlewares/CMSIS/DSP/Src/CommonTables/: CommonTables.c
    ../Middlewares/CMSIS/DSP/Src/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Middlewares/CMSIS/DSP/Src/ControllerFunctions/: ControllerFunctions.c
    ../Middlewares/CMSIS/DSP/Src/DistanceFunctions/: DistanceFunctions.c
    ../Middlewares/CMSIS/DSP/Src/FastMathFunctions/: FastMathFunctions.c
    ../Middlewares/CMSIS/DSP/Src/FilteringFunctions/: FilteringFunctions.c
    ../Middlewares/CMSIS/DSP/Src/InterpolationFunctions/: InterpolationFunctions.c
    ../Middlewares/CMSIS/DSP/Src/MatrixFunctions/: MatrixFunctions.c
    ../Middlewares/CMSIS/DSP/Src/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Middlewares/CMSIS/DSP/Src/StatisticsFunctions/: StatisticsFunctions.c
    ../Middlewares/CMSIS/DSP/Src/SupportFunctions/: SupportFunctions.c
    ../Middlewares/CMSIS/DSP/Src/SVMFunctions/: SVMFunctions.c
    ../Middlewares/CMSIS/DSP/Src/TransformFunctions/: TransformFunctions.c
    ../Middlewares/CMSIS/DSP/Src/WindowFunctions/: WindowFunctions.c
  group UI
    ../User/UI/: ui.h ui_default_init0_0.c ui_default_init0_0.h ui_default_init0_1.c ui_default_init0_1.h ui_default_init0_2.c ui_default_init0_2.h ui_default_init1_0.c ui_default_init1_0.h ui_default_init2_0.c ui_default_init2_0.h ui_default_init3_0.c ui_default_init3_0.h ui_default_init4_0.c ui_default_init4_0.h ui_default_init5_0.c ui_default_init5_0.h ui_default_init5_1.c ui_default_init5_1.h ui_default_init5_2.c ui_default_init5_2.h ui_default_init5_3.c ui_default_init5_3.h ui_default_init6_0.c ui_default_init6_0.h ui_interface.c ui_interface.h ui_types.h
  group Leg
    ../User/Leg/: chassisL.c chassisR.c mymath.c observe.c vmc.c get_K.c ppo_actor.c actor_xcube.c
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c
  group Doc
    ../X-CUBE-AI/App/: network_generate_report.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM4_Keil.lib
